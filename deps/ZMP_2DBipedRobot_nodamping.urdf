Commit message: "URDF joint modification for the boom"

File: deps/ZMP_2DBipedRobot_nodamping.urdf (robot description, URDF)
Before this commit: robot BipedalRobot, 15 links, 14 joints
Joints:
- joint base_boom_to_link_boom_joint_x: axis 0 0 1 -> 1 0 0; type prismatic -> revolute
